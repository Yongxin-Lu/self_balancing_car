# Repository Yongxin-Lu/self_balancing_car

File README.md:

# self_balancing_car
a stm32 self-balancing car. include pcb board, code and model.

WORK IN PROGRESS...

STM32遥控平衡车

代码还不完善，功能勉强能运行

## KiCad design pcb/car_mainboard/project_stander_elec.kicad_pcb

Parts:
BZ1: Buzzer; PUIAudio_SMT_0825_S_4_R
C1, C7, C11, C18, C24, C27, C29, C31, C32: 0.1uF; C_0603_1608Metric
C2, C4, C20, C22: 10uF; C_0603_1608Metric
C5: 2.2uf; C_0603_1608Metric
C6, C9, C12, C15: 22uF; CP_EIA-3216-10_Kemet-I_Pad1.58x1.35mm_HandSolder
C8, C10, C21: 0.1uf; C_0603_1608Metric
C14, C16: 22uF; C_0805_2012Metric
C17: 10nF; C_0603_1608Metric
C19: 2.2nF; C_0603_1608Metric
C23: 100uF; CP_EIA-3528-21_Kemet-B
C33: 1uF; C_0603_1608Metric
D1: Blue; LED_0603_1608Metric
D2: Green; LED_0603_1608Metric
D3: 25%; LED_0603_1608Metric
D4: 50%; LED_0603_1608Metric
D5: 75%; LED_0603_1608Metric
D6, D8: 100%; LED_0603_1608Metric
D7: 1N5819; D_SMA
J1: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J2: Battery_CON; PinSocket_1x02_P2.00mm_Vertical
J3: MOTOR1_CON; JST_ZE_SM06B-ZESS-TB_1x06-1MP_P1.50mm_Horizontal
J5: MOTOR2_CON; JST_ZE_SM06B-ZESS-TB_1x06-1MP_P1.50mm_Horizontal
J6: SWD_CON; JST_SH_BM05B-SRSS-TB_1x05-1MP_P1.00mm_Vertical
J7: 2.4G_CON; ai-thinker_2.4G_NF03_1.27mm
L4: 2.2uH; L_Abracon_ASPI-0630LR
Q3: S8050; SOT-23
R1, R4, R5, R10, R11: 4.7k; R_0603_1608Metric
R2, R6, R15, R16: 200; R_0603_1608Metric
R3: 2R; R_0603_1608Metric
R7, R12, R13, R14, R17, R18: 10k; R_0603_1608Metric
R8: 1k; R_0603_1608Metric
R9: 0.5R; R_0805_2012Metric
R19: 5.1k; R_0603_1608Metric
SW1: SW_Push; 3x6x3.5_SW_side
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: IP5306; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias
U3: MPU6050; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm
U4: DRV8833CPWP; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_The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
U5: CH340E; MSOP-10_3x3mm_P0.5mm
U6: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y2: 8MHz; Resonator_SMD_muRata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: BZ1.1 (-), C1.1, C7.1, C17.2, C21.1, C22.1, C23.1, C27.2, C29.2, C31.2, C32.2, C33.2, J3.5, J5.5, J6.1, J7.1, R1.2, R4.2, R5.2, R10.2, R11.2, R12.1, U1.2 (VO), U3.8 (VLOGIC), U3.13 (VDD), U5.7 (VCC), U5.10 (V3), U6.1 (VBAT), U6.9 (VDDA), U6.24 (VDD), U6.36 (VDD), U6.48 (VDD)
+5V: C6.1, C9.1, C12.1, C15.1, D7.2 (A), R19.1, U2.8 (VOUT), U4.12 (VM)
/ADC_BATT: C11.2, R17.1, R18.2, U6.14 (PA4)
/BATT+: C16.1, J2.1, L4.1, R9.1, R17.2
/Buzzer: R8.1, U6.33 (PA12)
/D+: J1.3 (D+), U5.1 (UD+)
/D-: J1.2 (D-), U5.2 (UD-)
/MOTOR1_1: C10.2, J3.1, U4.2 (AOUT1)
/MOTOR1_2: C10.1, J3.6, U4.4 (AOUT2)
/MOTOR1_AIN1: R2.1, U6.12 (PA2)
/MOTOR1_AIN2: R6.1, U6.13 (PA3)
/MOTOR1_C1: J3.3, U6.11 (PA1)
/MOTOR1_C2: J3.4, U6.10 (PA0)
/MOTOR2_1: C8.2, J5.1, U4.7 (BOUT1)
/MOTOR2_2: C8.1, J5.6, U4.5 (BOUT2)
/MOTOR2_BIN1: R15.1, U6.19 (PB1)
/MOTOR2_BIN2: R16.1, U6.18 (PB0)
/MOTOR2_C1: J5.3, U6.16 (PA6)
/MOTOR2_C2: J5.4, U6.17 (PA7)
/MPU6050_INT: U3.12 (INT), U6.20 (PB2)
/RF_CE: J7.3, U6.32 (PA11)
/RF_CSN: J7.4, U6.25 (PB12)
/RF_IRQ: J7.8, U6.29 (PA8)
/RF_MIOS: J7.7, U6.27 (PB14)
/RF_MOSI: J7.6, U6.28 (PB15)
/RF_SCK: J7.5, U6.26 (PB13)
/SCL: R10.1, U3.23 (SCL), U6.21 (PB10)
/SDA: R11.1, U3.24 (SDA), U6.22 (PB11)
/SWDCLK: J6.5, U6.37 (PA14)
/SWDIO: J6.4, U6.34 (PA13)
/UART1_RX: U5.8 (TXD), U6.43 (PB7)
/UART1_TX: U5.9 (RXD), U6.42 (PB6)
/USER_LED: D2.1 (K), U6.38 (PA15)
/VBUS: C4.1, J1.1 (VBUS), R3.1, U2.1 (VIN)
/nRST: C24.1, J6.3, R12.2, U6.7 (NRST)
unnamed: BZ1.2 (+), Q3.3 (C)
unnamed: C2.1, R3.2
unnamed: C5.2, U4.14 (VINT)
unnamed: C14.1, R9.2, U2.6 (BAT)
unnamed: C18.2, U3.10 (REGOUT)
unnamed: C19.2, U3.20 (CPOUT)
unnamed: C20.1, D7.1 (K), U1.3 (VI)
unnamed: D1.2 (A), R4.1
unnamed: D2.2 (A), R5.1
unnamed: D3.1 (K), D4.2 (A), D5.1 (K), D6.2 (A), U2.4 (LED3)
unnamed: D3.2 (A), D4.1 (K), U2.2 (LED1)
unnamed: D5.2 (A), D6.1 (K), U2.3 (LED2)
unnamed: D8.1 (K), U4.8 (nFAULT)
unnamed: D8.2 (A), R1.1
unnamed: L4.2, U2.7 (SW)
unnamed: R2.2, U4.16 (AIN1)
unnamed: R6.2, U4.15 (AIN2)
unnamed: R7.1, U2.5 (KEY)
unnamed: R7.2, SW1.1
unnamed: R14.1, U6.44 (BOOT0)
unnamed: R15.2, U4.9 (BIN1)
unnamed: R16.2, U4.10 (BIN2)
unnamed: R19.2, U4.1 (nSLEEP)
unnamed: U6.5 (PD0), Y2.1
unnamed: U6.6 (PD1), Y2.3

Notes on the sheet:
MPU6050
Power & User LED
STM32F103C8T6
DRV8833CPWP
IP5306
AMS1117-3.3V
CH340E
Buzzer
ADC

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
Board: 2 copper layers, 53.0 x 45.0 mm, 71 parts (2 on the bottom side), 62 nets.

## KiCad design pcb/24rf_remote_control/24RF_Remote_Control.kicad_pcb

Board: 4 copper layers, 34.9 x 51.2 mm, 71 parts (36 on the bottom side), 62 nets.

Parts:
BZ1: Buzzer; MLT-4020
C1, C4, C5, C12, C13, C14, C18, C33: 1uF; C_0603_1608Metric
C2, C3, C15: 4.7uF; C_0603_1608Metric
C7: 10nF; C_0603_1608Metric
C8, C10, C11, C24, C27, C29, C31, C32: 0.1uF; C_0603_1608Metric
C9: 2.2nF; C_0603_1608Metric
C16: 2.2uF; C_0603_1608Metric
C17: 100uF; CP_EIA-3528-21_Kemet-B
C19, C20, C21: 100nF; C_0603_1608Metric
D1: USER; C_0603_1608Metric
D2: CHG; C_0603_1608Metric
D4: POWER; C_0603_1608Metric
D6: 1N4148WT; D_SOD-523
J1: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J2: SWD; JST_SH_BM05B-SRSS-TB_1x05-1MP_P1.00mm_Vertical
J3: 24RF; ai-thinker_2.4G_NF03_1.27mm
J4: Conn_01x30; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal
J5: BATT_CON; PinHeader_1x02_P2.54mm_Vertical
Q1: S8050-Transistor_BJT; SOT-23
R1, R18, R20, R21, R22, R25: 10k; C_0603_1608Metric
R2: 15k; C_0603_1608Metric
R3, R8: 1.5k; C_0603_1608Metric
R4: 3k; C_0603_1608Metric
R5, R6, R7, R23: 5.1k; C_0603_1608Metric
R9, R10, R26: 10R; C_0603_1608Metric
R11, R13: 4.7k; C_0603_1608Metric
R12, R14: 10k; R_0603_1608Metric
R17: 1k; C_0603_1608Metric
R19: 910K; C_0603_1608Metric
S1: EG1218; SW_SPDT_CK-JS102011SAQN
SW1: LEFT; SW_SPST_CK_RS282G05A3
SW2: RIGHT; SW_SPST_CK_RS282G05A3
U1: BQ24075; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm_ThermalVias
U2: LP5912; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
U3: TPD4S012; TPD4S012DRYR
U4: STM32F103CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm_ThermalVias
U5: MPU6050-Sensor_Motion; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm
U7: W25Q128JVS; W25Q128BVEIG
U8: FJ08K-Joystick; FJ08K
Y2: 8MHz; Resonator_SMD_muRata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C5.1, C7.1, C10.1, C11.2, C12.1, C14.1, C17.1, C27.2, C29.2, C31.2, C32.2, C33.2, J2.1, J3.1, J4.6, J4.9, R5.1, R6.1, R7.2, R8.2, R11.1, R12.1, R13.1, R23.1, R26.1, S1.1, U2.1, U4.1, U4.9, U4.24, U4.36, U4.48, U5.8, U5.13, U7.3, U7.7, U7.8, U8.3, U8.6
/ADC_BATT: C19.1, R21.2, R22.1, U4.10
/BATT: C2.2, J5.1, R21.1, U1.2, U1.3
/BATT_OUT: C3.1, C4.1, U1.5, U1.10, U1.11, U2.4, U2.6
/BUTTON_RIGHT: C21.1, SW2.1, U4.14
/BUTTON__LEFT: C20.1, SW1.1, U4.22
/Buzzer: R17.1, U4.21
/CHARGE: D2.1, U1.9, U4.38
/D+: R9.1, U4.33
/D-: R10.1, U4.32
/FLASH_CS: U4.2, U7.1
/JY_X: R25.1, U4.15
/JY_Y: R20.1, U4.20
/MPU_INT: U4.16, U5.12
/MPU_SCL: R11.2, U4.18, U5.23
/MPU_SDA: R13.2, U4.17, U5.24
/OLED_CS: J4.13, U4.46
/OLED_DC: J4.15, U4.42
/OLED_FLASH_MISO: U4.40, U7.2
/OLED_FLASH_MOSI: J4.19, U4.41, U7.5
/OLED_FLASH_SCK: J4.18, U4.39, U7.6
/OLED_RES: J4.14, U4.43
/PGOOD: R6.2, U1.7, U4.13
/RF_CE: J3.3, U4.30
/RF_CSN: J3.4, U4.29
/RF_IRQ: J3.8, U4.25
/RF_MISO: J3.7, U4.27
/RF_MOSI: J3.6, U4.28
/RF_SCK: J3.5, U4.26
/SWDCLK: J2.5, U4.37
/SWDIO: J2.4, U4.34
/USER_LED: D1.1, U4.19
/nRST: C24.1, J2.3, R12.2, U4.7
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C14.2, C15.2, C16.2, C17.2, C19.2, C20.2, C21.2, C24.2, C27.1, C29.1, C31.1, C32.1, C33.1, D4.1, J1.5, J1.6, J2.2, J3.2, J4.1, J4.8, J4.10, J4.11, J4.12, J4.16, J4.17, J4.20, J4.21, J4.22, J4.23, J4.24, J4.25, J4.29, J4.30, J5.2, Q1.2, R1.2, R2.1, R3.1, R4.1, R14.2, R18.2, R19.2, R22.2, S1.3, SW1.2, SW2.2, U1.4, U1.6, U1.8, U1.17, U2.5, U2.7, U3.4, U4.8, U4.23, U4.35, U4.47, U4.49, U5.1, U5.9, U5.11, U5.18, U7.4, U8.1, U8.4, Y2.2
unnamed: BZ1.1, D6.1, R26.2
unnamed: BZ1.2, D6.2, Q1.3
unnamed: C1.2, J1.1, U1.13, U3.6
unnamed: C8.1, U5.10
unnamed: C9.1, U5.20
unnamed: C13.1, J4.4
unnamed: C13.2, J4.5
unnamed: C15.1, J4.27
unnamed: C16.1, J4.28
unnamed: C18.1, J4.2
unnamed: C18.2, J4.3
unnamed: D1.2, R23.2
unnamed: D2.2, R5.2
unnamed: D4.2, R7.1
unnamed: J1.2, R10.2, U3.1
unnamed: J1.3, R8.1, R9.2, U3.2
unnamed: J4.26, R19.1
unnamed: Q1.1, R17.2, R18.1
unnamed: R1.1, U1.1
unnamed: R2.2, U1.14
unnamed: R3.2, U1.12
unnamed: R4.2, U1.16
unnamed: R14.1, U4.44
unnamed: R20.2, U8.2
unnamed: R25.2, U8.5
unnamed: S1.2, U1.15
unnamed: U4.5, Y2.1
unnamed: U4.6, Y2.3

## Code that names these connections

File code/2.4rf_code/Hardwar_Drivers/inc/key_charge.h:

/*
 * key_charge.h
 *
 *  Created on: 2020Äê7ÔÂ15ÈÕ
 *      Author: simonlu
 */

#ifndef __KEY_CHARGE_H
#define __KEY_CHARGE_H 

#include "stm32f10x.h"

/*
Button Left:   PB11
Button Right:  PA4
	
Charge Detect: PA15
PGood Detect:  PA3	
*/
#define BUTTON_LEFT_PORT       GPIOB
#define BUTTON_RIGHT_PORT      GPIOA
#define CHARGE_DETECT_PORT  	 GPIOA
#define PGOOD_DETECT_PORT   	 GPIOA

#define BUTTON_LEFT_PIN        GPIO_Pin_11
#define BUTTON_RIGHT_PIN       GPIO_Pin_4
#define CHARGE_DETECT_PIN   	 GPIO_Pin_15
#define PGOOD_DETECT_PIN    	 GPIO_Pin_3

void Key_Charge_Init(void);
void Key_Charge_GPIO_Init(void);
void Key_Charge_INT_Init(void);

#endif /* KEY_CHARGE_H_ */

## Commit log

2020-08-14 2020/08/14 11:11 Commit
2020-08-14 add volt detect
2020-08-15 lower the baundrate and tx dbm to saving the power
2020-08-15 fix some bug
2020-08-16 add main gui
2020-08-23 edit readme.md

Notices in the files:
pcb/24rf_remote_control/24RF_Remote_Control.kicad_pcb:
© 2020 Simon Lu
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
