# Keil uVision project rf24_control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rf24_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\StdPeriph_Drivers\inc;.\Hardwar_Drivers\inc;.\CMSIS\device;.\CMSIS\core;.\Source;.\Hardwar_Drivers\src\eMPL;.\applications
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: main.c stm32f10x_it.c
  group Applications
    ./applications/: snake.c
  group Hardware_Drivers
    ./Hardwar_Drivers/src/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Hardwar_Drivers/src/: led.c mpu6050.c mpuiic.c buzzer.c oled.c si24r1.c adc.c key_charge.c w25q128.c hardware.c systick.c
  group StdPeriph_Drivers
    ./StdPeriph_Drivers/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/core/: core_cm3.c
    ./CMSIS/device/: system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
